# IAR project PROJ_V11.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151CC ST STM32L151CC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: C:\Проекты\Климатический модуль\Климат_итог\V1.1\inc; C:\Проекты\Климатический модуль\Климат_итог\V1.1\; C:\Проекты\Климатический модуль\Климат_итог\V1.1\console\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: Climat_module.bin
  ILINK.IlinkOutputFile: PROJ_V11.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group inc
    inc/: ADC.h core_cm3.h core_cmFunc.h core_cmInstr.h DAC.h Fan_Control.h Fan_Speed.h FSM_Analyzis.h FSM_FB_Control.h FSM_Get_Val.h FSM_State_Control.h GPIO.h GPIO_PERIPH.h HDC_I2C.h I2C.h LED_Control.h MAX_I2C.h Messages.h misc.h Report.h SpeedCounter.h stm32l1xx.h stm32l1xx_adc.h stm32l1xx_conf.h stm32l1xx_dac.h stm32l1xx_dma.h stm32l1xx_exti.h stm32l1xx_gpio.h stm32l1xx_i2c.h stm32l1xx_it.h stm32l1xx_rcc.h stm32l1xx_tim.h stm32l1xx_usart.h system_stm32l1xx.h Timers.h UART.h uart_deb.h
    ./: main.h
  group src
    src/: ADC.c DAC.c Fan_Control.c Fan_Speed.c FSM_Analyzis.c FSM_FB_Control.c FSM_Get_Val.c FSM_State_Control.c GPIO.c GPIO_PERIPH.c HDC_I2C.c I2C.c LED_Control.c MAX_I2C.c Messages.c misc.c Report.c SpeedCounter.c stm32l1xx_adc.c stm32l1xx_dac.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_it.c stm32l1xx_rcc.c stm32l1xx_tim.c stm32l1xx_usart.c system_stm32l1xx.c Timers.c UART.c uart_deb.c
    ./: main.c
  group startup
    startup/: startup_stm32l1xx_md.s
