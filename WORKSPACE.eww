<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\V1.1\PROJ_V11.ewp</path>
    </project>
    <batchBuild />
</workspace>
